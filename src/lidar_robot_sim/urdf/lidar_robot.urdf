Commit message: added DMAP generator

File: src/lidar_robot_sim/urdf/lidar_robot.urdf (robot description, URDF)
Before this commit: robot lidar_robot, 2 links, 1 joints
Joints:
- joint laser_joint: origin xyz=0.175 0 0.125 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 0
